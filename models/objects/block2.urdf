Commit message: new urdfs

File: models/objects/block2.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- removed link block_2_base_link
- added link block2_base_link, mass 0.02; collision box size=0.15 0.30 0.15; visual box size=0.15 0.30 0.15
