Commit message: updated gt contact factor viz, added logging to json

File: models/objects/block.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- link block_2_base_link: geometry collision box size=0.30 0.15 0.05; visual box size=0.30 0.15 0.05
